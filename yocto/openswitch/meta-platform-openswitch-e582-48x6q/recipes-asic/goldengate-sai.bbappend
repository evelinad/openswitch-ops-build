# Copyright (C) 2016 Centec Networks (suzhou) Co., Ltd. All Rights Reserved.

PR_append = "_e582_48x6q"


SRC_URI[md5sum] = "0cc6ec5d3547a4be9b436cf28c97b641"
SRC_URI[sha256sum] = "97b5782c036b94549f18fea014e287ba73d3fb1b3f85423b0f5a7591c04e73e3"
