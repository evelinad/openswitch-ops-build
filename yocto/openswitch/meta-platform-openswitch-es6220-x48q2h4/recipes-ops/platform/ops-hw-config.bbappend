# Copyright (C) 2016 EmbedWay Technologies (Shanghai) Corporation. All Rights Reserved.

PR_append = "_es6220_x48q2h4"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

PLATFORM_PATH = "EmbedWay/ES6220-X48Q2H4"
